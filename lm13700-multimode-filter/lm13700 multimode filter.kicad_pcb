# Repository toastynerd/modular_synth_schematics (continued)

## KiCad design vca_3360/3360 VCA.kicad_pcb

Parts:
C1, C2: 10uf; CP_Radial_D5.0mm_P2.00mm
C3: 4n7; C_Disc_D4.3mm_W1.9mm_P5.00mm
CV1KNOB1, CV2KNOB1: 100K; PinSocket_1x03_P2.54mm_Vertical
D1, D2: BZX55C2V0; D_DO-35_SOD27_P7.62mm_Horizontal
J1: Power in; PinSocket_1x03_P2.54mm_Vertical
J2: Input1; PinSocket_1x02_P2.54mm_Vertical
J3: CV1 In; PinSocket_1x02_P2.54mm_Vertical
J4: Input2; PinSocket_1x02_P2.54mm_Vertical
J5: CV2 In; PinSocket_1x02_P2.54mm_Vertical
J6: LED1; PinSocket_1x02_P2.54mm_Vertical
J7: LED2; PinSocket_1x02_P2.54mm_Vertical
J8: OUTPUT1; PinSocket_1x02_P2.54mm_Vertical
J9: OUTPUT2; PinSocket_1x02_P2.54mm_Vertical
Q1, Q2: 2N3904; TO-92_Inline
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R15, R16, R17, R19, R25, R26, R27, R28: 100K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R13, R14: 47K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R18, R20: 20K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R21, R23, R29, R30: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R22, R24: 6K8; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U1, U2: TL074; DIP-14_W7.62mm_Socket
U3: AS3360; DIP-14_W7.62mm_Socket

Connections:
+12V: C1.1, CV1KNOB1.1, CV2KNOB1.1, J1.1, R21.1, R23.1, U1.4 (V+), U2.4 (V+), U3.14 (VCC); also elsewhere on the board
-12V: C2.2, J1.3, U1.11 (V-), U2.11 (V-), U3.7 (VEE)
GND: C1.2, C2.1, C3.2, CV1KNOB1.3, CV2KNOB1.3, D1.1 (A), D2.1 (A), J1.2, J2.2, J3.2, J4.2, J5.2, J6.2, J7.2, J8.2, J9.2, R22.2, R24.2, U1.3 (+), U1.5 (+), U1.10 (+), U1.12 (+), U2.3 (+), U2.5 (+), U2.10 (+), U2.12 (+), U3.1 (GND); also elsewhere on the board
unnamed: C3.1, U3.8 (VREF)
unnamed 4: CV1KNOB1.2, R1.2; also elsewhere on the board
unnamed 5: CV2KNOB1.2, R4.2; also elsewhere on the board
unnamed: D1.2 (K), R13.1, U3.6 (II1)
unnamed: D2.2 (K), R14.1, U3.9 (II2)
unnamed: J2.1, R3.2
unnamed: J3.1, R2.2
unnamed: J4.1, R6.2
unnamed: J5.1, R5.2
unnamed: J6.1, Q1.1 (E)
unnamed: J7.1, Q2.1 (E)
unnamed: J8.1, R29.1
unnamed: J9.1, R30.1
unnamed: Q1.2 (B), R17.1
unnamed: Q1.3 (C), R21.2
unnamed: Q2.2 (B), R19.1
unnamed: Q2.3 (C), R23.2
unnamed: R1.1, R2.1, R8.2, U1.2 (-)
unnamed: R3.1, R7.2, U1.9 (-)
unnamed: R6.1, R9.2, U2.9 (-)
unnamed: R10.1, R12.2, U2.1
unnamed: R4.1, R5.1, R10.2, U2.2 (-)
unnamed: R11.1, R15.2, U1.6 (-)
unnamed: R8.1, R11.2, U1.1
unnamed: R12.1, R16.2, U2.6 (-)
unnamed: R7.1, R13.2, U1.8
unnamed: R9.1, R14.2, U2.8
unnamed: R15.1, R17.2, R18.2, U1.7
unnamed: R16.1, R19.2, R20.2, U2.7
unnamed: R18.1, R22.1, U3.5 (VC1)
unnamed: R20.1, R24.1, U3.10 (VC2)
unnamed: R25.1, R27.2, U1.13 (-)
unnamed: R25.2, U3.2 (IO1)
unnamed: R26.1, R28.2, U2.13 (-)
unnamed: R26.2, U3.13 (IO2)
unnamed: R27.1, R29.2, U1.14
unnamed: R28.1, R30.2, U2.14
unnamed: U3.3 (VE1), U3.4 (VO1)
unnamed: U3.11 (VO2), U3.12 (VE2)

Board: 2 copper layers, 100.0 x 56.0 mm, 51 parts (0 on the bottom side), 42 nets.

Other parts of the board:
CV1 KNOB, CV2 KNOB : 100K; PinSocket_1x03_P2.54mm_Vertical

Their connections:
+12V: CV1 KNOB.1, CV2 KNOB.1; also elsewhere on the board
GND: CV1 KNOB.3, CV2 KNOB.3; also elsewhere on the board
unnamed 4: CV1 KNOB.2; also elsewhere on the board
unnamed 5: CV2 KNOB.2; also elsewhere on the board

## KiCad design simple_mixer/simple mixer.kicad_pcb

Board: 2 copper layers, 49.5 x 48.5 mm, 16 parts (0 on the bottom side), 11 nets.

Parts:
C1, C2: 10uf; CP_Radial_D4.0mm_P1.50mm
J1: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J2: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RV1, RV2, RV3, RV4: 100k; PinHeader_1x03_P2.54mm_Vertical
U1: TL072; DIP-8_W7.62mm_Socket

Connections:
+12V: C2.1, J1.1, U1.8
-12V: C1.2, J1.3, U1.4
GND: C1.1, C2.2, J1.2, J2.2, RV1.3, RV2.3, RV3.3, RV4.3, U1.3, U1.5
unnamed: J2.1, R7.1, U1.7
unnamed: R1.1, RV1.2
unnamed: R1.2, R2.2, R3.2, R4.2, R5.2, U1.2
unnamed: R2.1, RV2.2
unnamed: R3.1, RV3.2
unnamed: R4.1, RV4.2
unnamed: R5.1, R6.2, U1.1
unnamed: R6.1, R7.2, U1.6

## Commit log

2020-12-26 fix readme typo
2020-12-26 add a word
2020-12-26 add some more info
2020-12-26 formatting
2020-12-28 schematic for 3360 vca done
2020-12-29 finish 3360 vca
2021-01-01 attenuverter and 3340 schematics
2021-01-05 add pcb layout for 3340
2021-01-07 3360 stencil and 3340 fixes
2021-02-10 three new modules with pcbs
2021-04-16 555 stencils and lm13700 stuff
2021-11-14 add: panels
2021-12-11 3340 panel
