# Repository toastynerd/modular_synth_schematics

File README.md:

# Modular Synth Schematics
Schematics ready to make PCBs for DIY modular synthesis. 

List of what I've gone through so far and what they're based off of.
Most of the projects here are based off of schematics I've found or data sheets but
the PCB layouts are my own. Feel free to use them for non-commercial applications.

Schematic and PCB file generated using [KiCad](https://kicad.org/)

STLs for panel stencils created using [Fusion360](https://www.autodesk.com/products/fusion-360/overview)

Modules are made in the [Kosmo](https://www.lookmumnocomputer.com/modular) format unless otherwise noted.

* [simple mixer](https://www.lookmumnocomputer.com/projects#/mixer)
* [AS3360 VCA](https://www.lookmumnocomputer.com/projects#/1181-dual-vca)

## KiCad design lm13700-multimode-filter/lm13700 multimode filter.kicad_pcb

Parts:
C1, C2, C5, C6, C7: 10uf; CP_Radial_D5.0mm_P2.00mm
C3, C4: 0.22nf; C_Disc_D5.0mm_W2.5mm_P5.00mm
J1: Power In; PinHeader_1x03_P2.54mm_Vertical
J2: Audio In; PinHeader_1x02_P2.54mm_Vertical
J3: CV-in; PinHeader_1x02_P2.54mm_Vertical
J4: High Pass; PinHeader_1x02_P2.54mm_Vertical
J5: Band Pass; PinHeader_1x02_P2.54mm_Vertical
J6: Low pass; PinHeader_1x02_P2.54mm_Vertical
Q1, Q2: 2N3906; TO-92_Inline
R1, R2, R3, R4, R5, R6, R7, R11, R29: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R8, R17: 200k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R9, R10, R16, R18, R19, R23, R24, R25, R26, R27, R28: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R12, R14, R20, R21: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R13: 47k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R15, R22: 68k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RV1: a100k; PinHeader_1x03_P2.54mm_Vertical
RV2: 1M; PinHeader_1x03_P2.54mm_Vertical
RV3: 100k; Potentiometer_Runtron_RM-065_Vertical
U1: TL074; DIP-14_W7.62mm_Socket
U2: TL072; DIP-8_W7.62mm_Socket
U3: LM13700; DIP-16_W7.62mm_Socket

Connections:
+12V: C1.1, J1.1, R20.1, RV1.1, U1.4 (V+), U2.8 (V+), U3.11 (V+)
-12V: C2.2, J1.3, R15.2, R22.2, RV3.3, U1.11 (V-), U2.4 (V-), U3.6 (V-)
GND: C1.2, C2.1, C3.2, C4.2, J1.2, J2.2, J3.2, J4.2, J5.2, J6.2, Q1.3 (C), Q2.2 (B), R9.2, R10.2, R16.2, R18.2, R19.2, R23.1, R24.2, R25.2, RV1.3, RV3.1, U1.3 (+), U2.3 (+), U2.5 (+)
unnamed: C3.1, U3.10, U3.12
unnamed: C4.1, U3.5, U3.7
unnamed: C5.1, U1.6 (-), U1.7
unnamed: C5.2, R23.2, R26.2
unnamed: C6.1, U1.8, U1.9 (-)
unnamed: C6.2, R24.1, R27.2
unnamed: C7.1, U1.13 (-), U1.14
unnamed: C7.2, R25.1, R28.2
unnamed: J2.1, R1.2
unnamed: J3.1, R3.2
unnamed: J4.1, R26.1
unnamed: J5.1, R27.1
unnamed: J6.1, R28.1
unnamed: Q1.1 (E), Q2.1 (E), R20.2
unnamed: Q1.2 (B), R13.1, R14.1, R16.1
unnamed: Q2.3 (C), R12.2, R21.2
unnamed: R1.1, R2.2, R5.2, R6.2, U1.2 (-)
unnamed: R2.1, R22.1, U1.12 (+), U3.8
unnamed: R3.1, R4.1, R7.2, U2.2 (-)
unnamed: R4.2, RV1.2
unnamed: R5.1, RV2.1, RV2.2
unnamed: R6.1, R8.2, U1.1, U1.5 (+)
unnamed: R8.1, R9.1, U3.14 (+)
unnamed: R10.1, U3.13 (-)
unnamed: R11.1, R13.2, U2.7
unnamed: R11.2, R29.1, U2.6 (-)
unnamed: R12.1, U3.16
unnamed: R14.2, RV3.2
unnamed: R15.1, R17.2, RV2.3, U1.10 (+), U3.9
unnamed: R17.1, R18.1, U3.3 (+)
unnamed: R19.1, U3.4 (-)
unnamed: R21.1, U3.1
unnamed: R7.1, R29.2, U2.1

Board: 2 copper layers, 65.0 x 95.0 mm, 50 parts (0 on the bottom side), 36 nets.

## KiCad design simple-vclfo/SImple VCLFO.kicad_pcb

Parts:
C1, C2: 10uf; CP_Radial_D5.0mm_P2.00mm
C3: 100nf; C_Disc_D5.0mm_W2.5mm_P5.00mm
D1: LED 1; PinHeader_1x02_P2.54mm_Vertical
J1: Power In; PinHeader_1x03_P2.54mm_Vertical
J2: CV In 1; PinHeader_1x02_P2.54mm_Vertical
J4: Tri 1; PinHeader_1x02_P2.54mm_Vertical
J5: Square 1; PinHeader_1x02_P2.54mm_Vertical
Q1, Q3: 2N3904; TO-92_Inline
R1, R2, R5, R6, R9, R12, R28, R32: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R11, R13, R14, R20, R25: 47k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R19, R21: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R24, R27: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RV1: Freq 1; PinHeader_1x03_P2.54mm_Vertical
U1: TL074; DIP-14_W7.62mm_Socket

Connections:
+12V: C1.1, D1.2 (A), J1.1, RV1.1, U1.4 (V+)
-12V: C2.2, J1.3, U1.11 (V-)
GND: C1.2, C2.1, J1.2, J2.2, J4.2, J5.2, Q1.1 (E), R14.2, R20.2, R24.2, R32.2, RV1.3, U1.3 (+), U1.5 (+)
unnamed: C3.1, R21.2, R27.2, U1.8, U1.13 (-)
unnamed: C3.2, R12.1, R13.1, U1.9 (-)
unnamed: D1.1 (K), Q3.3 (C)
unnamed: J2.1, R2.2
unnamed: J4.1, R27.1
unnamed: J5.1, R28.1, R32.1
unnamed: Q1.2 (B), R19.2
unnamed: Q1.3 (C), R13.2
unnamed: Q3.1 (E), R24.1
unnamed: Q3.2 (B), R21.1
unnamed: R1.1, R2.1, R5.2, U1.2 (-)
unnamed: R1.2, RV1.2
unnamed: R5.1, R6.2, U1.1
unnamed: R6.1, R9.2, U1.6 (-)
unnamed: R11.1, R14.1, U1.10 (+)
unnamed: R9.1, R11.2, R12.2, U1.7
unnamed: R19.1, R25.1, R28.2, U1.14
unnamed: R20.1, R25.2, U1.12 (+)

Board: 2 copper layers, 29 parts (0 on the bottom side), 21 nets.

## KiCad design vco_3340/vco_3340.kicad_pcb

Parts:
C1: 100nf; C_Disc_D5.0mm_W2.5mm_P5.00mm
C2, C3, C4, C8: 1nf; C_Disc_D5.0mm_W2.5mm_P5.00mm
C5, C6, C7, C9: 10uf; CP_Radial_D5.0mm_P2.00mm
J1: cv1; PinHeader_1x02_P2.54mm_Vertical
J2: cv2; PinHeader_1x02_P2.54mm_Vertical
J3: FM in; PinHeader_1x02_P2.54mm_Vertical
J4: PWM; PinHeader_1x02_P2.54mm_Vertical
J5: Sync In; PinHeader_1x03_P2.54mm_Vertical
J6: Power In; PinHeader_1x03_P2.54mm_Vertical
J7: Pulse Out; PinHeader_1x02_P2.54mm_Vertical
J8: Saw Out; PinHeader_1x02_P2.54mm_Vertical
J9: Tri Out; PinHeader_1x02_P2.54mm_Vertical
R1, R2, R3, R5, R6: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R4, R9: 1M; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R7: 1M5; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R8, R17: 470R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R10: 12M; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R11: 620r; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R12: 470k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R13: 24k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R14: 5.6k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R15: 1.8k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R16: 47k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R18: 100K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RV1: Coarse Tune; PinHeader_1x03_P2.54mm_Vertical
RV2: Fine Tune; PinHeader_1x03_P2.54mm_Vertical
RV3: Pulse Width; PinHeader_1x03_P2.54mm_Vertical
RV4: 20k; Potentiometer_Runtron_RM-065_Vertical
RV5: 10k; Potentiometer_Runtron_RM-065_Vertical
U1: TL072; DIP-8_W7.62mm_Socket
U2: AS3340; DIP-16_W7.62mm_Socket
U3: TL074; DIP-14_W7.62mm_Socket
U4: L7805; TO-220-3_Vertical

Connections:
+5V: C9.1, RV2.1, RV3.1, U4.3
+12V: C5.1, C7.1, J6.1, R7.2, RV1.1, U1.8 (V+), U2.16 (VCC), U3.4 (V+), U4.1
-12V: C6.2, J6.3, R11.2, U1.4 (V-), U3.11 (V-)
GND: C4.2, C5.2, C6.1, C7.2, C8.1, C9.2, J1.2, J2.2, J3.2, J4.2, J5.2, J6.2, J7.2, J8.2, J9.2, R8.2, R15.2, R16.1, RV1.3, RV2.3, RV3.3, RV4.3, U2.12 (GND), U4.2
unnamed: C1.1, R9.2
unnamed: C1.2, J3.1
unnamed: C2.1, U2.6 (VHSI)
unnamed: C2.2, J5.1
unnamed: C3.1, U2.9 (VSSI)
unnamed: C3.2, J5.3
unnamed: C4.1, U2.11 (CAP)
unnamed: C8.2, R17.1
unnamed: J1.1, R3.2
unnamed: J2.1, R2.2
unnamed: J4.1, R5.2
unnamed: J7.1, U3.1, U3.2 (-)
unnamed: J8.1, U3.6 (-), U3.7
unnamed: J9.1, U3.8, U3.9 (-)
unnamed: R1.1, R2.1, R3.1, R4.1, U1.5 (+)
unnamed: R1.2, RV1.2
unnamed: R4.2, RV2.2
unnamed: R5.1, R6.1, U1.3 (+)
unnamed: R6.2, RV3.2
unnamed: R7.1, R8.1, R9.1, U2.13 (VLFI)
unnamed: R10.1, R17.2, R18.1, U2.15 (VFCI)
unnamed: R10.2, RV4.2
unnamed: R11.1, R14.2, RV5.1, RV5.2, U2.3 (VEE)
unnamed: R12.1, U2.5 (VPWM)
unnamed: R12.2, U1.1, U1.2 (-)
unnamed: R13.1, U2.1 (SCALE1)
unnamed: R13.2, RV5.3
unnamed: R14.1, U2.2 (SCALE2)
unnamed: R15.1, U2.14 (VS)
unnamed: R16.2, U2.4 (VP), U3.3 (+)
unnamed: R18.2, U1.6 (-), U1.7
unnamed: RV4.1, U2.7 (VHFT)
unnamed: U2.8 (VSO), U3.5 (+)
unnamed: U2.10 (VTO), U3.10 (+)

Board: 2 copper layers, 55.0 x 95.0 mm, 45 parts (0 on the bottom side), 38 nets.

## KiCad design adsr-eg-555/adsr eg 555.kicad_pcb

Parts:
C1, C2, C4: 10uf; CP_Radial_D5.0mm_P2.00mm
C3: 10nf; C_Disc_D5.0mm_W2.5mm_P5.00mm
C5: 1uf; C_Disc_D4.7mm_W2.5mm_P5.00mm
D1, D2, D3, D4: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
D5: LED; PinHeader_1x02_P2.54mm_Vertical
J1: Gate; PinHeader_1x02_P2.54mm_Vertical
J2: Power In; PinHeader_1x03_P2.54mm_Vertical
J3: Out 2; PinHeader_1x02_P2.54mm_Vertical
J4: Out 1; PinHeader_1x02_P2.54mm_Vertical
Q1, Q2, Q3, Q4: 2N3904; TO-92_Inline
R1, R4: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3, R5, R6: 4.7k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R7: 5.6k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R8, R9: 100r; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R10, R11, R12, R13: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RV1: 10k; PinHeader_1x03_P2.54mm_Vertical
RV2, RV3, RV4: 1m; PinHeader_1x03_P2.54mm_Vertical
RV5: 10k; Potentiometer_Runtron_RM-065_Vertical
U1: TL074; DIP-14_W7.62mm_Socket
U2: NE555P; DIP-8_W7.62mm

Connections:
+12V: C1.1, D5.2 (A), J2.1, R3.1, R5.1, R6.1, R7.1, U1.4 (V+), U2.8 (VCC)
-12V: C2.2, J2.3, U1.11 (V-)
GND: C1.2, C2.1, C4.2, C5.2, D1.2 (A), J1.2, J2.2, J3.2, J4.2, Q1.1 (E), Q2.1 (E), Q3.1 (E), R2.2, R11.2, RV5.3, U2.1 (GND)
unnamed: C3.1, D1.1 (K), Q3.2 (B)
unnamed: C3.2, Q2.3 (C), R5.2, R8.2, U2.4 (R)
unnamed: C4.1, U2.5 (CV)
unnamed: C5.1, D2.2 (A), D3.2 (A), D4.1 (K), U1.5 (+), U2.6 (THR)
unnamed: D2.1 (K), RV4.2, RV4.3
unnamed: D3.1 (K), RV2.1
unnamed: D4.2 (A), RV3.1
unnamed: D5.1 (K), Q4.3 (C)
unnamed: J1.1, R1.1
unnamed: J3.1, R13.1
unnamed: J4.1, R12.1
unnamed: Q1.2 (B), R1.2, R2.1
unnamed: Q1.3 (C), R3.2, R4.2
unnamed: Q2.2 (B), R4.1
unnamed: Q3.3 (C), R6.2, U2.2 (TR)
unnamed: Q4.1 (E), R11.1
unnamed: Q4.2 (B), RV5.1, U1.6 (-), U1.7
unnamed: R7.2, RV1.3
unnamed: R8.1, RV2.2, RV2.3
unnamed: R9.1, RV3.2, RV3.3
unnamed: R9.2, U2.3 (Q)
unnamed: R10.1, RV4.1
unnamed: R10.2, U1.1, U1.2 (-)
unnamed: R12.2, U1.8, U1.9 (-)
unnamed: R13.2, U1.13 (-), U1.14
unnamed: RV1.1, U2.7 (DIS)
unnamed: RV1.2, U1.3 (+)
unnamed: RV5.2, U1.10 (+), U1.12 (+)

Board: 2 copper layers, 53.0 x 95.0 mm, 38 parts (0 on the bottom side), 31 nets.
